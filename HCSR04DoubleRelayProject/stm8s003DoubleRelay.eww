<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm8s003DoubleRelayPrj.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>123</name>
      <member>
        <project>stm8s003DoubleRelayPrj</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


